# Keil uVision project BasicUI.uvproj, settings and files
target KL25Z Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: BasicUI
  AfterMake: "C:\Users\Rahul\Documents\ECE 561\Projects\561_Project_2\ProfilerProject - Base\Scripts\update_regions_MDK.bat"
  c flags: Optim=4
  c misc: --fpmode=fast
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ./src/: system_MKL25Z4.c
    ./asm/: startup_MKL25Z4.s
  group source
    ./src/: LCD_4bit.c main.c LEDs.c timers.c i2c.c mma8451.c delay.c sine_table.c profile.c region.c spi.c triggers.c v2xe.c
